Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2020-11-27T09:28:21
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.4.0.0 - Alternate UI 18.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Fri Nov 27 09:28:21 2020* Host: BIMServices* Database: C:\Users\PIOTRB~1\AppData\Local\Temp\{B1980B3A-5F9E-406E-900D-F8B3DE5C637D}\ifc* Database version: 5507* Database creation date: Fri Nov 27 09:28:20 2020* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Fri Nov 27 09:28:20 2020* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Fri Nov 27 09:28:20 2020* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcDistributionPort, Port_351407
Description: Flow; FlowDirection: SINK

# IfcFlowTerminal: ARTIS_SurfaceMountedWashbasin_580x380, NBS_VilleroyAndBoch_CntrTopWshBsns_ARTIS_SurfaceMountedWashbasin_417258:ARTIS_SurfaceMountedWashbasin_580x380:351407
In: Level 0
Type - PredefinedType: WASHHANDBASIN; Classification: Pr_40_20_96_18 (Uniclass2015); Material: NBS_Concept
Type - BOS_General - Author: NBS; BIMObjectName: NBS_VilleroyAndBoch_CounterTopWashBasins_ARTIS_SurfaceMountedWashbasin_417258; ManufacturerName: Villeroy & Boch; ManufacturerURL: https://pro.villeroy-boch.com/en/gb/home.html; NBSCertification: www.nationalbimlibrary.com/cert/o5rblogf; NBSDescription: Counter top wash basins; NBSReference: 45-35-70/360; ProductInformation: https://www.villeroy-boch.co.uk/bathroom-and-wellness/products/Artis-Surface-mounted-washbasin-Rectangle-417258.html; Revision: n/a; Uniclass2015Title: Countertop washbasins; Uniclass2015Code: Pr_40_20_96_18; Uniclass2015Version: Products v1.17; Version: 1
Type - NBS_Data - Accessories: Non-closable drain valve; Weight: 11.5 kg; OverflowClass: Without overflow; TapFitting: For wall-mounted washbasin mixers or tall pillar tap fittings, without tap hole area; ColourOptions: White alpin, powder, ballet, rose, macaroon, lemon, mustard, full moon, french linen, coal black, fog, frost, ocean, mint, sencha, cedar
Type - Pset_SanitaryTerminalTypeCommon - NominalLength: 0 mm; Color: n/a; NominalDepth: 380 mm; NominalWidth: 580 mm; Reference: n/a
Type - Pset_SanitaryTerminalTypeWashHandBasin - MountingOffset: 0 mm; DrainSize: 45 mm; Mounting: COUNTERTOP; WashHandBasinType: VANITY
Type - IFC - IfcExportAs: IfcSanitaryTerminalType; IfcExportType: WASHHANDBASIN
Type - COBie - NominalHeight: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_40_20_96_18:Countertop washbasins; CodePerformance: EN 31, EN 14688; Constituents: n/a; Description: Surface mounted washbasin; DurationUnit: year; ExpectedLife: n/a; Features: Multiple colours available, wrap around edging, quick and easy to clean, long lasting; Finish: Scratch and impact-resistant; Grade: n/a; Manufacturer: marketing@villeroy-boch.co.uk; Material: TitanCeram; ModelNumber: 417258; ModelReference: ARTIS_SurfaceMountedWashbasin_580x380; Name: CounterTopWashBasins_ARTIS_SurfaceMountedWashbasin_417258_VilleroyAndBoch; ReplacementCost: n/a; Shape: Rectangular; Size: 580 x 380 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
